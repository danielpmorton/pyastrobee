Commit message: Fix misaligned positioning and mass of top_aft link

File: pyastrobee/assets/urdf/astrobee/astrobee.urdf (robot description, URDF)
Before this commit: robot astrobee, 8 links, 7 joints
Links:
- link honey_top_aft: mass 0.3078 -> 0.11225
